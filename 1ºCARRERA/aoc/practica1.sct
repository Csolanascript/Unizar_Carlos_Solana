LR_IRAM1 0x40000000 0x00008000  {  ; load region
 ER_IRAM1 0x40000000 {  ; RW data
   * (+RO +RW +ZI)
 }
}