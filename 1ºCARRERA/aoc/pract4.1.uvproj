# Keil uVision project pract4.1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2105 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: pract4.1
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
    E:/: wuolah-free-practica4-2.s
  group c
    E:/: main.c
